# IAR project Navota.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NV32F100 Navota NV32F100
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: Navota\CMSIS; Navota\PERIPH; Application; RTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Navota\NV32F100_SRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: Navota\CMSIS; Navota\PERIPH
  OBJCOPY.OOCOutputFile: Navota.srec
  group Application
    Application/: main.c
  group Navota/CMSIS
    Navota/CMSIS/: NV32.h startup_NV32.s system_NV32.c system_nv32.h
  group Navota/PERIPH
    Navota/PERIPH/: NV32_acmp.c NV32_acmp.h NV32_adc.c NV32_adc.h NV32_bitband.h NV32_BME.h NV32_config.h NV32_crc.c NV32_crc.h NV32_etm.c NV32_etm.h NV32_flash.c NV32_flash.h NV32_gpio.c NV32_gpio.h NV32_i2c.c NV32_i2c.h NV32_ics.c NV32_ics.h NV32_kbi.c NV32_kbi.h NV32_pit.c NV32_pit.h NV32_pmc.c NV32_pmc.h NV32_rtc.c NV32_rtc.h NV32_sim.c NV32_sim.h NV32_spi.c NV32_spi.h NV32_uart.c NV32_uart.h NV32_wdog.c NV32_wdog.h
